v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {opa_mod1.sym} 0 20 0 0 {name=x1}
