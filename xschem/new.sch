v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {opam.sym} -20 50 0 0 {name=x1}
